# Keil uVision project RDA5981.uvprojx, settings and files
target RDA5981 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: rda5981 +hex
  AfterMake: fromelf.exe  --bin -o  ./rda5981.bin  ./obj/rda5981.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\src;.\src\cmsis;.\src\cmsis\TARGET_RDA\TARGET_UNO_91H;.\src\cmsis\TARGET_RDA\TARGET_UNO_91H\TOOLCHAIN_ARM_STD\TARGET_UNO_81C;.\src\hal;.\src\hal\TARGET_RDA;.\src\hal\TARGET_RDA\TARGET_UNO_91H\TOOLCHAIN_ARM_STD;.\src\hal\TARGET_RDA\TARGET_UNO_91H;.\src\api;.\src\api\storage_abstraction;.\src\device\Inc
  asm include: .\src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\src\RDA5981C.sct
  group qitas
    ./src/: main.c
  group SYS
    ./src/cmsis/TARGET_RDA/TARGET_UNO_91H/TOOLCHAIN_ARM_STD/: startup_RDA5991H.S
    ./src/cmsis/TARGET_RDA/TARGET_UNO_91H/: system_RDA5991H.c cmsis_nvic.c
  group device
    ./src/device/: PIN_MAP.c UART.c
